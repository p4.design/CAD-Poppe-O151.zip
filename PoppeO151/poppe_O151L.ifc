Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: poppe_o151.ifc.ifc
Time: 2016-09-30T13:57:07
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Poppe O151
ePset_BIMobject_Lena - Seat Material: Black Leather; Chair Type: O151L; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Poppe O151; SKU (BO_prodsku): O151; ManufacturName (BO_Manufac): Blￃﾥ Station; ProductFamily (BO_prodfam): Chairs; ProductGroup (BO_prodgroup): Poppe; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 9/6/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 350; Height (BO_height): 1200; Depth (BO_depth): 650; Weight (BO_weight): 8.2; QR (BO_boqrurl): http://bimobject.com/blastation/product/O151; ProductDataUrl (BO_prodaturl): bimobject.com/blastation/product/O151; MaterialMain (BO_mainmat): Upholstery; MaterialSecondary (BO_secmat): Steel; BimObjectCategory (BO_bocat): Office Chairs; IfcClassification (BO_ifcclas): Furniture; Uniclass14Code (BO_uniclass_1_4_code): L8211; Uniclass14Description (BO_uniclass_1_4_desc): Furniture; NBSReference (BO_nbs_ref): 31-12; NBSReferenceDescription (BO_nbs_desc): Chairs, Seats And Bench Seating; MasterFormat2014Code (BO_masterformat2014_code): 12 00 00; MasterFormat2014Description (BO_masterformat2014_name): Furnishings; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
